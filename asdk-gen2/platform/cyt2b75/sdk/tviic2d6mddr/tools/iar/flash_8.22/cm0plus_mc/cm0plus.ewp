# IAR project cm0plus.ewp, settings and files
configuration rev_a (ARM, debug)
  General.OGChipSelectEditMenu: CYT4EN_M0+ Infineon CYT4EN_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviic2d6mddr; CYT4ENDBQS; CY_USE_PSVP=0; CY_MCU_rev_a; CY_500BGA_EVK_rev_a
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_a; ..\..\..\..\hdr\rev_a\ip; ..\..\..\..\hdr\rev_a\mcureg; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\interrupts\rev_a; ..\..\..\..\src\mw; ..\..\..\..\src\system\rev_a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm0plus.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __cm7_0_rom
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviic2d6mddr.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a; ..\libmw\rev_a\cm0plus\libmw.a; ..\libsdl\rev_a\cm0plus\libsdl.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_a
    ../../../../hdr/rev_a/: bb_bsp_tviic2d6mddr.h cy_device_headers.h cyt4en_config.h
  group hdr/rev_a/ip
    ../../../../hdr/rev_a/ip/: cyip_axi_dmac.h cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom_v5.h cyip_ipc.h cyip_jpegdec.h cyip_lin.h cyip_lpddr4.h cyip_mixer.h cyip_pass.h cyip_pd.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v5.h cyip_smif_v4.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group src
    ../../../../src/: main_cm0plus.c
  group src/interrupts/rev_a
    ../../../../src/interrupts/rev_a/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm0plus.s
  group src/system/rev_a
    ../../../../src/system/rev_a/: system_tviic2d6mddr.h system_tviic2d6mddr_cm0plus.c
